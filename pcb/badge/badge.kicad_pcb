File: pcb/badge/badge.kicad_pcb (KiCad board)
At the start: 2 copper layers, 55.2 x 54 mm, 39 parts, among them IC1 VS1053B, J1 AudioJack4_Ground, J2 Conn_01x04_Male, J3 Conn_01x08_Male, U1 AMS1117-1.8, U2 AMS1117-3.3, Y1 12.288M

Commit message: Routing the CPU
Parts:
- removed J2: Conn_01x04_Male, Connector_PinSocket_2.54mm:PinSocket_1x04_P2.54mm_Vertical
- added C24: 4.7uF, Capacitor_SMD:C_0603_1608Metric, F.Cu at (94.5, 81.3)
- added C25: 100nF, Capacitor_SMD:C_0603_1608Metric, F.Cu at (109.2, 88.9)
- added C26: 100nF, Capacitor_SMD:C_0603_1608Metric, F.Cu at (98.3, 91.4)
- added C27: 1uF, Capacitor_SMD:C_0603_1608Metric, F.Cu at (98.6, 76.2)
- added C28: 1uF, Capacitor_SMD:C_0603_1608Metric, F.Cu at (102.1, 76.2)
- added C29: 1uF, Capacitor_SMD:C_0603_1608Metric, F.Cu at (109.2, 83.8)
- added C30: 1uF, Capacitor_SMD:C_0603_1608Metric, F.Cu at (105.4, 81.3)
- added C31: 1uF, Capacitor_SMD:C_0603_1608Metric, F.Cu at (109.2, 78.7)
- added C32: 1uF, Capacitor_SMD:C_0603_1608Metric, F.Cu at (99.1, 86.4)
- added C33: 1uF, Capacitor_SMD:C_0603_1608Metric, F.Cu at (110.5, 72.4)
- added C34: 1uF, Capacitor_SMD:C_0603_1608Metric, F.Cu at (94.8, 76.2)
- added C35: 1uF, Capacitor_SMD:C_0603_1608Metric, F.Cu at (107.2, 72.4)
- added D1: MBR0530, Diode_SMD:D_SOD-123, F.Cu at (101.6, 71.1)
- added D2: MBR0530, Diode_SMD:D_SOD-123, F.Cu at (100.3, 81.3)
- added D3: MBR0530, Diode_SMD:D_SOD-123, F.Cu at (104.1, 86.4)
- added J4: USB_B_Micro, Connector_USB:USB_Micro-B_Molex-105017-0001, F.Cu at (45.7, 83.8)
- added J5: Conn_01x08_Male, Connector_PinHeader_2.54mm:PinHeader_1x08_P2.54mm_Vertical, F.Cu at (83.8, 71.1)
- added J6: Conn_01x04_Male, Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical, F.Cu at (64.8, 87.6)
- added J7: PFC24/0.5mm, Connector_FFC-FPC:Hirose_FH12-24S-0.5SH_1x24-1MP_P0.50mm_Horizontal, F.Cu at (115.6, 87.6)
- added L1: 68uH, Inductor_SMD:L_1210_3225Metric, F.Cu at (115.7, 72.4)
- added Q1: Si1308EDL, Package_TO_SOT_SMD:SOT-323_SC-70, F.Cu at (106.7, 94.0)
- added R10: 10K, Resistor_SMD:R_0603_1608Metric, F.Cu at (91.4, 76.2)
- added R11: 3R, Resistor_SMD:R_0603_1608Metric, F.Cu at (105.4, 76.2)
- added U3: E73-2G4M08S1C, EBYTE:E73-2G4M08S1C, F.Cu at (50.8, 100.3)
- added U4: touch-slider-4pin, touch-buttons:TouchSlider-4_50x10mm, B.Cu at (80.2, 118.1)
- added U5: touch-button, touch-buttons:TOUCH-CIRCLE, B.Cu at (48.3, 116.8)
- added U6: touch-button, touch-buttons:TOUCH-CIRCLE, B.Cu at (115.6, 116.8)
- J1: value AudioJack4_Ground -> AudioJack4
- moved C4 60.7 mm to (52.5, 81.8), turned to 90 degrees
- moved U2 56.5 mm to (63.2, 80.9)
- moved C6 55.4 mm to (57.7, 80.0)
- moved C12 54.2 mm to (55.2, 79.8)
- moved J1 25.1 mm to (50.8, 72.4)
- moved R3 19.4 mm to (68.4, 69.8)
- moved R4 19.4 mm to (68.4, 72.4)
- moved R2 19.4 mm to (68.4, 74.9)
- moved C21 19.4 mm to (74.3, 69.8)
- moved C22 19.4 mm to (74.3, 72.4)
- moved C20 19.4 mm to (74.3, 74.9)
Connections:
- net /DREQ renamed /SNDDREQ
- net /GBUF renamed /SheetMP3/GBUF
- net /GPIO-R renamed /SheetMP3/GPIO-R
- net /LEFT renamed /SheetMP3/LEFT
- net /RIGHT renamed /SheetMP3/RIGHT
- net /XRESET renamed /SNDRESET
- net /xCS renamed /SNDCS
- net /xDCS renamed /SNDxDCS
Routing:
- net /TouchBTN2: track 0.00 -> 73.5 mm, vias 0 -> 1
- net /SCLK: track 27.8 -> 82.8 mm, vias 1 -> 2
- net /MOSI: track 34.7 -> 88.9 mm, vias 1 -> 2
- net Net-(U3-Pad10): track 0.00 -> 43.0 mm, vias 0 -> 1
- net +3V3: track 150.4 -> 192.9 mm
- net /DISPBUSY: track 0.00 -> 39.8 mm, vias 0 -> 1
- net /SNDDREQ: track 16.8 -> 56.4 mm, vias 1 -> 2
- net /DISPRST: track 0.00 -> 39.5 mm, vias 0 -> 1
- net /DISPCS: track 0.00 -> 36.8 mm, vias 0 -> 1
- net /SNDxDCS: track 21.8 -> 57.8 mm, vias 1 -> 3
- net /DISPDC: track 0.00 -> 34.5 mm, vias 0 -> 1
- net Net-(U3-Pad9): track 0.00 -> 31.9 mm, vias 0 -> 1
- net /SheetMP3/RIGHT: track 37.8 -> 68.2 mm
- net /SNDCS: track 26.8 -> 50.3 mm
- net Net-(U3-Pad8): track 0.00 -> 20.7 mm, vias 0 -> 1
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- removed copper zone on B.Cu, net GND
- removed copper zone on F.Cu, net GND
Other:
- board size 55.2 x 54 mm -> 80 x 57.1 mm
- board text removed: "3.3V"
- board text removed: "5V"

Commit message: Finish routing for display
Parts:
- moved R10 29.2 mm to (107.4, 100.6), turned to 180 degrees
- moved L1 24.3 mm to (99.6, 90.5), turned to 270 degrees
- moved C26 19.8 mm to (117.1, 85.3), turned to 180 degrees
- moved C34 18.7 mm to (107.2, 90.2), turned to 180 degrees
- moved R11 17.9 mm to (107.2, 94.0), turned to 180 degrees
- moved C25 16.8 mm to (96.0, 78.5), turned to 180 degrees
- moved C32 16.1 mm to (107.2, 72.4), turned to 180 degrees
- moved C35 15.2 mm to (107.2, 87.6), turned to 180 degrees
- moved D1 13.9 mm to (95.2, 83.4), turned to 90 degrees
- moved D3 12.9 mm to (100.3, 74.0), turned to 90 degrees
- moved C27 12.4 mm to (107.2, 85.1), turned to 180 degrees
- moved J7 8.67 mm to (115.8, 96.3)
- moved C28 8.13 mm to (107.2, 82.5), turned to 180 degrees
- moved C24 7.14 mm to (96.5, 88.1), turned to 90 degrees
- moved C29 4.33 mm to (107.2, 80.0), turned to 180 degrees
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Routing:
- net +3V3: track 192.9 -> 271.2 mm
- net /DISPDC: track 34.5 -> 79.0 mm, vias 1 -> 3
- net /DISPRST: track 39.5 -> 81.8 mm, vias 1 -> 3
- net /DISPBUSY: track 39.8 -> 81.1 mm, vias 1 -> 3
- net /SCLK: track 82.8 -> 121.3 mm, vias 2 -> 3
- net /DISPCS: track 36.8 -> 74.8 mm, vias 1 -> 3
- net /Epaper/PREVGL: track 0.00 -> 30.7 mm
- net /MOSI: track 88.9 -> 119.0 mm, vias 2 -> 3
- net Net-(C25-Pad1): track 0.00 -> 25.9 mm
- net /Epaper/PREVGH: track 0.00 -> 25.5 mm
- net Net-(C33-Pad1): track 0.00 -> 23.2 mm
- net Net-(U3-Pad7): track 14.2 -> 36.6 mm
- net Net-(C31-Pad1): track 0.00 -> 19.5 mm
- net Net-(U3-Pad9): track 31.9 -> 49.2 mm
- net Net-(C29-Pad1): track 0.00 -> 15.8 mm
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- added copper zone on B.Cu, net GND
- added copper zone on F.Cu, net GND

Commit message: Add power and indication LEDs
Parts:
- added D4: LED, LED_SMD:LED_0603_1608Metric, F.Cu at (58.0, 90.6)
- added D5: LED, LED_SMD:LED_0603_1608Metric, F.Cu at (47.3, 110.9)
- added R12: 470R, Resistor_SMD:R_0603_1608Metric, F.Cu at (62.2, 90.6)
- added R13: 470R, Resistor_SMD:R_0603_1608Metric, F.Cu at (81.8, 112.1)
Connections:
- U3 pad 1: (no net) -> Net-(D5-Pad1)
Routing:
- net Net-(D5-Pad2): track 0.00 -> 33.5 mm
- net +3V3: track 271.2 -> 275.9 mm
- net Net-(D5-Pad1): track 0.00 -> 4.05 mm
- net GND: track 98.0 -> 100.9 mm, vias 7 -> 8
- net Net-(D4-Pad2): track 0.00 -> 2.63 mm

Commit message: Add silk screen text for breakout pins
Other:
- board text added: "3V3"
- board text added: "AUDIO"
- board text added: "BUSY"
- board text added: "CLK"
- board text added: "CS"
- board text added: "D/C"
- board text added: "DISPLAY"
- board text added: "IO"
- board text added: "RST"
- board text added: "SWD"
Changed lines of the file:
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@@
   (general
     (thickness 1.6)
-    (drawings 21)
+    (drawings 36)
     (tracks 733)
     (zones 0)
@@
     (tags "capacitor tantalum")
     (attr smd)
-    (fp_text reference C12 (at -3.857 0 90) (layer F.SilkS)
+    (fp_text reference C12 (at 1.176 -1.835 90) (layer F.SilkS)
       (effects (font (size 1 1) (thickness 0.15)))
     )
@@
     (tags SOD-123)
     (attr smd)
-    (fp_text reference D2 (at 0 1.27 270) (layer F.SilkS)
+    (fp_text reference D2 (at 3.4 0.07 270) (layer F.SilkS)
       (effects (font (size 1 1) (thickness 0.15)))
     )
@@
     )
   )
+  (gr_text SWD (at 52.43 87.33) (layer F.SilkS)
+    (effects (font (size 1.5 1.5) (thickness 0.3)))
+  )
+  (gr_text AUDIO (at 69.32 98.98 270) (layer F.SilkS)
+    (effects (font (size 1.5 1.5) (thickness 0.3)))
+  )
+  (gr_text DISPLAY (at 80.55 79.82 270) (layer F.SilkS)
+    (effects (font (size 1.5 1.5) (thickness 0.3)))
+  )
+  (gr_text BUSY (at 87.07 88.55) (layer F.SilkS)
+    (effects (font (size 1 1) (thickness 0.2)))
+  )
+  (gr_text RST (at 87.07 86.51) (layer F.SilkS)
+    (effects (font (size 1 1) (thickness 0.2)))
+  )
+  (gr_text D/C (at 87.07 83.75) (layer F.SilkS)
+    (effects (font (size 1 1) (thickness 0.2)))
+  )
+  (gr_text CS (at 87.07 81.29) (layer F.SilkS)
+    (effects (font (size 1 1) (thickness 0.2)))
+  )
+  (gr_text SCLK (at 87.04 78.62) (layer F.SilkS)
+    (effects (font (size 1 1) (thickness 0.2)))
+  )
+  (gr_text MOSI (at 87.04 76.16) (layer F.SilkS)
+    (effects (font (size 1 1) (thickness 0.2)))
+  )
+  (gr_text GND (at 87.04 73.52) (layer F.SilkS)
+    (effects (font (size 1 1) (thickness 0.2)))
+  )
+  (gr_text 3V3 (at 87.04 71.2) (layer F.SilkS)
+    (effects (font (size 1 1) (thickness 0.2)))
+  )
+  (gr_text GND (at 56.77 85.39) (layer F.SilkS)
+    (effects (font (size 1 1) (thickness 0.2)))
+  )
+  (gr_text CLK (at 59.71 85.46) (layer F.SilkS)
+    (effects (font (size 1 1) (thickness 0.2)))
+  )
+  (gr_text IO (at 62.29 85.44) (layer F.SilkS)
+    (effects (font (size 1 1) (thickness 0.2)))
+  )
+  (gr_text 3V3 (at 64.89 85.48) (layer F.SilkS)
+    (effects (font (size 1 1) (thickness 0.2)))
+  )
   (gr_circle (center 89.7 101.1) (end 89.7 100.9) (layer F.SilkS) (width 0.2))
