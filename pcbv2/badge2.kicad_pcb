File: pcbv2/badge2.kicad_pcb (KiCad board)
At the start: 2 copper layers, 137.9 x 57.6 mm, 69 parts, among them J1 SOICbite, J2 SAO_CONN, J3 USB_C_Receptacle_USB2.0, J4 Conn_01x08_Female, J7 PFC24/0.5mm, Q1 Si1308EDL, Q2 Si1308EDL, SW4 SW_SPDT, U1 MCP73831-2-OT, U2 AMS1117-3.3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

Commit message: feat(pcbv2): add cross hole
Parts:
- added CROSS1: , badge:cross-u5, F.Cu at (249.7, 136.7)
